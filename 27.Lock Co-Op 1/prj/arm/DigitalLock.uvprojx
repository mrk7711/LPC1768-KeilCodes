# Keil uVision project DigitalLock.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DigitalLock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\inc;..\..\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../../src/: Hardware.c main.c TaskHandle.c TaskHandle_Port.c kbd.c Task_Refresh.c Task_Key.c
  group PH_Driver
    ../../Drivers/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_rit.c lpc17xx_systick.c lpc17xx_uart.c lpc17xx_rtc.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
